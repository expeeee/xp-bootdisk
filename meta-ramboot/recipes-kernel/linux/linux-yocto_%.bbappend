FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://vfio.cfg"
